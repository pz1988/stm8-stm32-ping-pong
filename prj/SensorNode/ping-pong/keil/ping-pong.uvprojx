# Keil uVision project ping-pong.uvprojx, settings and files
target SensorNode ping-pong (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ping-pong
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32_SENSERNODE_DELAY
  c include: ..\..\..\..\src\hal\SensorNode\peripherals;..\..\..\..\src\hal\SensorNode\system;..\..\..\..\src\hal\SensorNode\stm32_board;..\..\..\..\src\hal\SensorNode\stm32_board\cmsis;..\..\..\..\src\hal\SensorNode\stm32_board\cmsis\arm-std;..\..\..\..\src\hal\mcu\stm32;..\..\..\..\src\hal\mcu\stm32\cmsis;..\..\..\..\src\hal\mcu\stm32\STM32L1xx_StdPeriph_Driver\inc;..\..\..\..\src\drv;..\..\..\..\src\drv\radio;..\..\..\..\src\examples\SensorNode\ping-pong
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group apps
    ../../../../src/examples/SensorNode/ping-pong/: app.c main.c
  group hal\sensornode\system
    ../../../../src/hal/SensorNode/system/: gpio.c i2c.c spi.c timer-sensornode.c
  group hal\sensornode\peripheral
    ../../../../src/hal/SensorNode/peripherals/: gpio-ioe.c sx1509.c
  group hal\sensornode\stm32_board\cmsis
    ../../../../src/hal/SensorNode/stm32_board/cmsis/: system_stm32l1xx.c
    ../../../../src/hal/SensorNode/stm32_board/cmsis/arm-std/: startup_stm32l1xx_md.s
  group hal\sensornode\stm32_board
    ../../../../src/hal/SensorNode/stm32_board/: board.c gpio-board.c hal-irq.c hal-led.c hal-spi.c hal-sx1276.c hal-sys-clk.c hal-sys-tick.c hal-uart.c i2c-board.c timer-board.c
  group hal\mcu\stm32\stm32lixx_stdperiph_drivers
    ../../../../src/hal/mcu/stm32/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group hal\mcu\stm32
    ../../../../src/hal/mcu/stm32/: sysIrqHandlers.c utilities.c
  group drivers
    ../../../../src/drv/: led.c printf.c sys-tick.c uart.c
  group radio
    ../../../../src/drv/radio/: sx1276.c
