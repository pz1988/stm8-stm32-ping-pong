# IAR project ping-pong.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152K6 STM8L152K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ../../../src/hal/Huangshan; ../../../src/hal/mcu/stm8/STM8L15x_StdPeriph_Driver/inc; ../../../src/drv; ../../../src/drv/radio; ../../../src/examples/Huangshan/ping-pong
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ping-pong.srec
  ILINK.IlinkOutputFile: ping-pong.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group app
    ../../../src/examples/Huangshan/ping-pong/: app.c main.c
  group drv
    ../../../src/drv/: key.c lcd.c led.c printf.c sys-tick.c uart.c
  group drv/radio
    ../../../src/drv/radio/: sx1276.c
  group hal
    ../../../src/hal/Huangshan/: hal-irq.c hal-key.c hal-lcd.c hal-led.c hal-rtc.c hal-spi.c hal-sx1276.c hal-sys-clk.c hal-sys-tick.c hal-uart.c
